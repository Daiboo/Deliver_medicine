# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PZ Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: rvmdk PART_TM4C123GH6PZ TARGET_IS_BLIZZARD_RB1 __USE_ANSI_EXAMPLE_RAND
  c include: .\Libraries\driverlib;.\Libraries\inc;.\Libraries\utils;.\Drivers;.\System;.\User;.\Libraries;.\apply;.\apply\Fusion
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Inc
    ./Libraries/inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h tm4c123gh6pm.h
  group Libraries
    ./Libraries/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c adc.h aes.h can.h comp.h cpu.h crc.h debug.h des.h eeprom.h emac.h epi.h flash.h fpu.h gpio.h hibernate.h i2c.h interrupt.h lcd.h mpu.h pin_map.h pwm.h qei.h readme.txt rom.h rom_map.h rtos_bindings.h shamd5.h ssi.h sw_crc.h sysctl.h sysexc.h systick.h timer.h uart.h udma.h usb.h watchdog.h
  group Fusion
    ./apply/Fusion/: Fusion.h FusionAhrs.c FusionAhrs.h FusionAxes.h FusionCalibration.h FusionCompass.c FusionCompass.h FusionMath.h FusionOffset.c FusionOffset.h
  group apply
    ./apply/: Sensor.c Sensor.h wp_math.h wp_math.c filter.c filter.h motor_control.c motor_control.h pid.c pid.h sdk.h sdk.c develop_mode.c develop_mode.h subtask.h subtask.c ui.h ui.c gray_detection.h gray_detection.c vision.h vision.c
  group Drivers
    ./Drivers/: neeprom.h neeprom.c oledfont.h oled.h oled.c ssd1306.c ssd1306.h binary.h glcdfont.h nadc.h nadc.c Buzzer.c Buzzer.h NTimer.c NTimer.h ni2c.c ni2c.h icm20608.c icm20608.h npwm.c npwm.h nEncoder.c nEncoder.h nbutton.c nbutton.h nuart.h nuart.c rgb.c rgb.h Ultrasonic.c Ultrasonic.h
  group System
    ./System/: startup_rvmdk.S system.c system.h
  group User
    ./User/: main.c Headfile.h Datatype.h user.h tm4c12x_it.h tm4c12x_it.c
    ./Libraries/utils/: uartstdio.c uartstdio.h
